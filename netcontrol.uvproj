# Keil uVision project netcontrol.uvproj, settings and files
target iap (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iap_start +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc;.\STM32F10x_StdPeriph_Driver\inc;..\enc28j60_iap_start;.\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --symdefs=.\share.sym
  group Source
    ./src/: STM32F10x.s SPI.C main.c ENC28J60.C ip_arp_udp_tcp.c simple_server.c
  group StdPeriph_Driver
    ./CoreSupport/: core_cm3.c
    ./src/: misc.c stm32f10x_flash.c system_stm32f10x.c
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c
